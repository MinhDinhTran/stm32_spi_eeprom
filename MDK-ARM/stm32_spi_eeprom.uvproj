# Keil uVision project stm32_spi_eeprom.uvproj, settings and files
target stm32_spi_eeprom_DEBUG (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: stm32_spi_eeprom +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8
  c misc: --gnu
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\Middlewares\Third_Party\BSP;..\Middlewares\Third_Party
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Drivers/CMSIS
    ..//Src/: system_stm32f0xx.c
  group Application/User
    ../Src/: stm32f0xx_hal_msp.c stm32f0xx_it.c main.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_iwdg.c
  group MiddleWare/BSP
    ../Middlewares/Third_Party/BSP/: BSP_EEPROM.c DebugProbe.c
